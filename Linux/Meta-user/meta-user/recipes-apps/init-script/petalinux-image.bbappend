IMAGE_INSTALL_append = " init-script"
